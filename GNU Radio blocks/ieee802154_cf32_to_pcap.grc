options:
  parameters:
    author: Dimitrios-Georgios Akestoridis
    description: A simple GRC flow graph that demodulates previously captured I/Q samples.
    generate_options: qt_gui
    id: ieee802154_cf32_to_pcap
    output_language: python
    realtime_scheduling: '1'
    title: IEEE 802.15.4 I/Q Signal Demodulator
  states: {}

blocks:
- name: channel
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0
    label: Channel Number
    labels: '[]'
    num_opts: '0'
    options: '[11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26]'
    type: int
    value: '20'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2405000000 + 5000000*(channel - 11)
  states: {}
- name: freq_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,0
    label: Frequency (GHz)
    type: real
    value: freq / 1000000000.0
  states: {}
- name: page_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0
    label: Channel Page
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/ieee802154_1.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: '"/tmp/uhd-sr"+str(samp_rate)+"-freq"+str(freq)+".cf32"'
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '195'
  states: {}
- name: ieee802_15_4_oqpsk_phy_0
  id: ieee802_15_4_oqpsk_phy
  parameters: {}
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 4,0
    showports: 'True'
    type: complex
    wintype: window.WIN_HANN
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', ieee802_15_4_oqpsk_phy_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', blocks_null_sink_0, '0']
- [ieee802_15_4_oqpsk_phy_0, rxout, foo_wireshark_connector_0, in]

metadata:
  file_format: 1
